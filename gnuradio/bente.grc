options:
  parameters:
    generate_options: qt_gui
    id: bente
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 314e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: packet
  id: variable
  parameters:
    value: '"010100101011100011000001"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 4.17e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate/symbol_rate)
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '4'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[int(x) for x in packet]'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0b1000, 0b1110]'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.basic_block):\n    def __init__(self, signal_length=0, preamble=None, postamble=None, delay_length=0):\n        gr.basic_block.__init__(self, name=\"Signal Formatter\", in_sig=[np.byte], out_sig=[np.byte])\n\n        self.idx = 0\n        self.signal_length = signal_length\n        self.preamble = preamble or []\n        self.postamble = postamble or []\n        self.delay_length = delay_length\n\n    def general_work(self, input_items, output_items):\n        number_of_inputs_processed = 0\n        for i in range(len(output_items[0])):\n            if self.idx < len(self.preamble):\n                output_items[0][i] = self.preamble[self.idx]\n            elif self.idx < len(self.preamble) + self.signal_length:\n                output_items[0][i] = input_items[0][number_of_inputs_processed]\n                number_of_inputs_processed += 1\n            elif self.idx < len(self.preamble) + self.signal_length + len(self.postamble):\n                output_items[0][i] = self.postamble[self.idx - len(self.preamble) - self.signal_length]\n            else:\n                output_items[0][i] = 0\n\n            self.idx += 1\n            if self.idx == len(self.preamble) + self.signal_length + len(self.postamble) + self.delay_length:\n                self.idx = 0\n\n        self.consume(0, number_of_inputs_processed)\n        return len(output_items[0])\n\n"
    delay_length: '1024'
    postamble: '[1]'
    preamble: '[1] + [0] * 30'
    signal_length: '96'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/symbol_rate)
    taps: '1'
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_uchar_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_1, '0']
- [blocks_vector_source_x_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [epy_block_1, '0', blocks_uchar_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_moving_average_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
